# Keil uVision project test.uvproj, settings and files
target Electronic (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c bsp_delay.c bsp_key.c bsp_ds1302.c
