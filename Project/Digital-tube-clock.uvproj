# Keil uVision project Digital-tube-clock.uvproj, settings and files
target Electronic (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 89C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\User\bsp_delay;..\User\bsp_ds1302;..\User\bsp_ds18b20;..\User\bsp_key
  group Doc
    ../: readme.md
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c
    ../User/bsp_ds18b20/: bsp_ds18b20.c
    ../User/bsp_delay/: bsp_delay.c
    ../User/bsp_ds1302/: bsp_ds1302.c
    ../User/bsp_key/: bsp_key.c
